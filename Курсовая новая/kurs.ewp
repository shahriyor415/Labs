# IAR project kurs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: D:\DownloadsGoogle\dlu-kursocha\CortexLib; D:\DownloadsGoogle\dlu-kursocha\CortexLib\AbstractHardware; D:\DownloadsGoogle\dlu-kursocha\Kursovow\CMSIS; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos\include; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos\portable; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos\portable\IAR; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos\portable\IAR\ARM_CM4F; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\wrapper; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\wrapper\FreeRtos; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos\portable\Common; D:\DownloadsGoogle\dlu-kursocha\CortexLib\AbstractHardware\Registers; D:\DownloadsGoogle\dlu-kursocha\CortexLib\AbstractHardware\Registers\STM32F411; D:\DownloadsGoogle\dlu-kursocha\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; D:\DownloadsGoogle\dlu-kursocha\CortexLib\Common; D:\DownloadsGoogle\dlu-kursocha\CortexLib\AbstractHardware\InterruptHandler; D:\DownloadsGoogle\dlu-kursocha\CortexLib\AbstractHardware\Registers\CortexM4; D:\DownloadsGoogle\dlu-kursocha\CortexLib\AbstractHardware\Registers\CortexM4\FieldValues; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Applications; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Applications\Parameters; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Thread; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Hardware; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Hardware\ADC; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Hardware\DMA; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Hardware\PWM; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Hardware\Sender; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Hardware\USART2
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: D:\DownloadsGoogle\dlu-kursocha\Kursovow\CMSIS; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos\include; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos\portable; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos\portable\IAR; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos\portable\IAR\ARM_CM4F; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\wrapper; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\wrapper\FreeRtos; D:\DownloadsGoogle\dlu-kursocha\Kursovow\Rtos\FreeRtos\portable\Common
  OBJCOPY.OOCOutputFile: kurs.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: interrupthandler.hpp main.cpp StartUp.cpp
  group Applications
    Applications/: IDataSource.h
  group Applications/Parameters
    Applications/Parameters/: Filter.h IMeasureParameter.h Voltage.h
  group CMSIS
    CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h core_cm33.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f411xe.h stm32f4xx.h system_stm32f4xx.h
  group Hardware/ADC
    Hardware/ADC/: ADC.cpp ADC.h
  group Hardware/DMA
    Hardware/DMA/: DMA.h
  group Hardware/PWM
    Hardware/PWM/: PWM.cpp PWM.h
  group Hardware/Sender
    Hardware/Sender/: Sender.h
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/include
    Rtos/FreeRtos/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group Rtos/FreeRtos/portable/IAR/ARM_CM4F
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Thread
    Thread/: InSender.cpp InSender.h PowerRegulationTask.cpp PowerRegulationTask.h
